# Repository Zimengzhou/jlink_v9_copy

File README.md:

# DIY jlink_v9
自制Jlink，工具在手，效率我有
- 可以选择内置3.3V参考电平，也可以外部输入，内部有电平转换功能。
- 内置参考电平可以对小负载供电。

## 照片
- 顶部图  

- 底部图

## KiCad design copyDIY-jlinkV9.kicad_pcb

Parts:
C1, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30: 100nF; C_0603_1608Metric
C2, C3: 10pF; C_0603_1608Metric
C4, C5, C10: 4.7uF; C_0603_1608Metric
C6, C7, C8, C9: 1uF; C_0603_1608Metric
D1: Red; LED_0603_1608Metric
D2, D3: Green; LED_0603_1608Metric
F1: Fuse 500mA 6V; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2: MCU-SWD; PinSocket_1x05_P1.27mm_Vertical
J3: Conn_JTAG_SWD_10_szm; IDC-Header_2x05_P2.54mm_Horizontal
Q1: MMDT3608; SOT-363_SC-70-6
Q2, Q4: YJL2305; SOT-23
Q3, Q5: s8050-j3y; SOT-23
R1, R3, R5, R7, R8, R9, R10, R11: 22R; R_0603_1608Metric
R2, R4, R6, R14, R15, R17, R37, R38, R41, R42, R43, R44, R45, R46, R54, R55: 10k; R_0603_1608Metric
R12, R13: 5.1k; R_0603_1608Metric
R16: 47k; R_0603_1608Metric
R18, R19, R56: 3k; R_0603_1608Metric
R20: 2k; R_0603_1608Metric
R21: 5.1; R_0603_1608Metric
R22, R31, R32, R33: 100; R_0603_1608Metric
R23, R24, R25, R26, R27, R28, R29, R30, R34: 470; R_0603_1608Metric
R35, R36, R39, R40: 4.7k; R_0603_1608Metric
R47, R48, R49, R50, R51, R52, R53: 220k; R_0603_1608Metric
SW1: SW_Push_DPDT; SW_DPDT_SMD
U1: STM32F205RETx; LQFP-64_10x10mm_P0.5mm
U2: USBLC6-2SC6; SOT-23-6
U3, U4: RT9013; SOT-23-5_HandSoldering
U5, U6, U7: SN74LVC2T45DCUR; VSSOP-8_2.4x2.1mm_P0.5mm
U8, U9, U10: SN74LVC1T45DBV; SOT-23-6
U11: LMV321; SOT-23-5
Y1: Crystal_GND24_12MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C7.1, C10.1, C11.1, C12.1, C13.1, C14.1, C16.2, C18.2, C20.2, C22.2, C24.2, C26.2, C29.1, C30.1, D1.2 (A), D2.2 (A), J2.1, R2.1, R4.1, R14.1, R15.1, R37.2, R39.1, U1.1 (VBAT), U1.13 (VDDA), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U3.5 (Vout), U5.1 (VCCA), U6.1 (VCCA), U7.1 (VCCA), U8.1 (VCCA), U9.1 (VCCA), U10.1 (VCCA)
+5V: C6.1, C8.1, C15.1, F1.2, Q4.2 (S), R38.2, R43.2, SW1.6 (C), U2.5 (VBUS), U3.1 (VIN), U3.3 (EN), U4.1 (VIN), U11.5 (V+)
/MCU_RST: C1.1, J2.5, R2.2, U1.7 (NRST)
/STMUSB_DN: U1.44 (PA11), U2.3 (I/O2)
/STMUSB_DP: U1.45 (PA12), U2.1 (I/O1)
/STM_SWCLK: J2.3, R15.2, U1.49 (PA14)
/STM_SWDIO: J2.2, R14.2, U1.46 (PA13)
/USB_DN: J1.A7 (D-), J1.B7 (D-), U2.4 (I/O2)
/USB_DP: J1.A6 (D+), J1.B6 (D+), U2.6 (I/O1)
/nCTL1: U1.10 (PC2), U8.5 (DIR)
/nCTL3: U1.16 (PA2), U9.5 (DIR)
/nCTL4: U1.17 (PA3), U10.5 (DIR)
/nDAT01: R34.1, U1.43 (PA10)
/nDAT02: U1.41 (PA8), U5.3 (A2)
/nDAT03: U1.23 (PA7), U6.2 (A1)
/nDAT04: U1.40 (PC9), U6.3 (A2)
/nDAT05: R34.2, U1.39 (PC8)
/nDAT06: R30.1, U1.35 (PB14)
/nDAT07: R28.1, U1.22 (PA6)
/nDAT08: R1.2, R3.2, R8.2, R29.1
/nDAT09: U1.27 (PB1), U1.33 (PB12)
/nDAT10: U1.28 (PB2), U7.2 (A1)
/nDAT11: R5.2, R9.2, R10.2, U5.2 (A1)
/nDAT12: U1.25 (PC5), U7.3 (A2)
/nPWR: Q5.2 (E), R40.1, U1.59 (PB7)
/nSRST: R35.1, U1.61 (PB8)
/pADC1: R41.1, R42.2, U1.8 (PC0)
/pADC2: R7.2, R11.2, R45.1, R46.2
/pADC4: R43.1, R44.2, U1.14 (PA0)
/pLED1: R18.2, U1.30 (PB11)
/pLED2: R19.2, U1.29 (PB10)
GND: C1.2, C2.1, C3.1, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.2, C30.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J2.4, J3.3 (GND), J3.5 (GND), Q3.2 (E), R6.2, R12.1, R13.2, R16.2, R17.2, R36.1, R42.1, R44.1, R46.1, R47.1, R48.1, R49.1, R50.1, R51.1, R52.1, R53.1, R55.1, R56.2, U1.12 (VSSA), U1.18 (VSS), U1.63 (VSS), U2.2 (GND), U3.2 (GND), U4.2 (GND), U5.4 (GND), U5.5 (DIR), U6.4 (GND), U6.5 (DIR), U7.4 (GND), U7.5 (DIR), U8.2 (GND), U9.2 (GND), U10.2 (GND), U11.2 (V-), Y1.2, Y1.4
IREF3V3pwr: C9.1, Q1.1 (E1), Q2.3 (D), U4.5 (Vout)
NRESET: J3.10 (~RESET), Q3.3 (C), R26.2, R37.1, R47.2
unnamed: D1.1 (K), R18.1
unnamed: D2.1 (K), R19.1
unnamed: D3.2 (A), R55.2, SW1.5 (B), U4.3 (EN)
unnamed: D3.1 (K), R56.1
unnamed: F1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
unnamed: J1.A5 (CC1), R13.1
unnamed: J1.B5 (CC2), R12.2
unnamed: Q1.2 (B1), Q1.5 (B2), Q1.6 (C1), R16.1
unnamed: Q1.3 (C2), Q2.1 (G), R17.1
unnamed: Q3.1 (B), R35.2, R36.2
unnamed: Q4.1 (G), Q5.3 (C), R38.1
unnamed: Q5.1 (B), R39.2, R40.2
unnamed: R4.2, R6.1, U1.60 (BOOT0)
unnamed: R1.1, U1.21 (PA5)
unnamed: R3.1, U1.34 (PB13)
unnamed: R5.1, U1.36 (PB15)
unnamed: R7.1, U1.9 (PC1)
unnamed: R11.1, U1.11 (PC3)
unnamed: R8.1, U1.37 (PC6)
unnamed: R9.1, U1.38 (PC7)
unnamed: R10.1, U1.53 (PC12)
unnamed: C2.2, U1.5 (PH0), Y1.3
unnamed: C3.2, U1.6 (PH1), Y1.1
unnamed: C4.1, U1.31 (VCAP_1)
unnamed: C5.1, U1.47 (VCAP_2)
unnamed: R22.1, U5.7 (B1)
unnamed: R23.1, U5.6 (B2)
unnamed: R24.1, U6.7 (B1)
unnamed: R25.1, U6.6 (B2)
unnamed: R27.1, U7.7 (B1)
unnamed: R26.1, U7.6 (B2)
unnamed: R28.2, U8.3 (A)
unnamed: R31.1, U8.4 (B)
unnamed: R29.2, U9.3 (A)
unnamed: R32.1, U9.4 (B)
unnamed: R30.2, U10.3 (A)
unnamed: R33.1, U10.4 (B)
unnamed: R21.1, U11.3 (-), U11.4
VCC_Ref: C17.2, C19.2, C21.2, C23.2, C25.2, C27.2, R21.2, R41.2, R54.2, U5.8 (VCCB), U6.8 (VCCB), U7.8 (VCCB), U8.6 (VCCB), U9.6 (VCCB), U10.6 (VCCB)
VREF: R20.2, U11.1 (+)
Vout: J3.7 (VOUT), Q4.3 (D), R45.2
tRXD: J3.9 (RXD), R27.2, R53.2, R54.1
tTCK: J3.4 (SWDCLK/TCK), R25.2, R32.2, R48.2
tTDI: J3.8 (NC/TDI), R23.2, R33.2, R51.2
tTDO: J3.6 (SWO/TDO), R22.2, R50.2
tTMS: J3.2 (SWDIO/TMS), R24.2, R31.2, R49.2
tVREF: C28.2, J3.1 (VTref), Q1.4 (E2), Q2.2 (S), R20.1, R52.2

Notes on the sheet:
内部3.3V参考电压
电平转换
Arm Debug JTAG线序
STM32f205ret6
USB Type-C && Power
5V VOUT
ADCs
https://developer.arm.com/documentation/101636/0100/Debug-and-Trace/JTAG-SWD-Interface

Board: 4 copper layers, 37.0 x 72.5 mm, 111 parts (20 on the bottom side), 81 nets.

## Commit log

2024-06-27 原理图及PCB文件
2024-06-27 上传照片
2024-06-27 添加Gerber制板文件和BOM表
